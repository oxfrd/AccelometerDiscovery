<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Accelerometer_LSM303CTR.ewp</path>
  </project>
  <batchBuild />
</workspace>
